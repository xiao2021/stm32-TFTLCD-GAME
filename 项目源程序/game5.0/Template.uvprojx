# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: .\Libraries\CMSIS;.\Libraries\STM32F1xx_HAL_Driver\Inc;.\User;.\Public;.\APP\led;.\APP\beep;.\APP\key;.\APP\exti;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\touch_key;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\lsens;.\APP\dac;.\APP\pwm_dac;.\APP\dma;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\ds18b20;.\APP\hwjs;.\APP\rs485;.\APP\can;.\APP\tftlcd;.\APP;.\APP\touch;.\APP\24Cxx;.\APP\iic;.\APP\openmv_data;.\APP\music
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f1xx_it.c system_stm32f1xx.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f103xe.s
  group HAL_Driver
    ./Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_usart.c stm32f1xx_hal_uart.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_can.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sram.c
  group CMSIS
    ./Libraries/CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm3.h
  group APP
    ./APP/led/: led.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/: logic.c
    ./APP/touch/: touch.c gt5663.c ctiic.c
    ./APP/key/: key.c
    ./APP/iic/: iic.c
    ./APP/24Cxx/: 24cxx.c
    ./APP/openmv_data/: openmv_data.c
    ./APP/music/: music.c
  group Public
    ./Public/: system.c SysTick.c usart.c
